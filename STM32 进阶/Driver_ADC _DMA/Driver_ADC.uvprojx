# Keil uVision project Driver_ADC.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Driver_ADC +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Start;.\User;.\User\Common;.\User\Hardware;.\User\Driver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Start
    ./Start/: core_cm3.c core_cm3.h startup_stm32f10x_hd.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group User
    ./User/: main.c
  group User/Hardware
    ./User/Hardware/: LED.c LED.h key.h Key.c EEPROM.c EEPROM.h
  group User/Common
    ./User/Common/: Delay.c Delay.h
  group User/Driver
    ./User/Driver/: USART.c USART.h IIC2.c IIC2.h Systick.c systick.h TIM6.c TIM6.h TIM5.c TIM5.h TIM4.c TIM4.h TIM1.c TIM1.h DMA1.c DMA1.h ADC1.c ADC1.h
