# Keil uVision project P38_LCD_register.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\00_arm5_compiler)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: P01_LED_register +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\User;.\Start;.\Hardware\led;.\Hardware\key;.\Hardware\usart;.\Hardware\i2c;.\Hardware\tim;.\Hardware\dma;.\Hardware\ADC;.\Hardware\spi;.\Hardware\fsmc;.\Hardware\lcd
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Start
    ./Start/: core_cm3.c core_cm3.h startup_stm32f10x_hd.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group User
    ./User/: main.c Delay.c
  group Hardware/led
    ./Hardware/led/: Driver_LED.c
  group Hardware/key
    ./Hardware/key/: Driver_Key.c
  group Hardware/usart
    ./Hardware/usart/: Driver_USART1.c
  group Hardware/i2c
    ./Hardware/i2c/: Driver_I2C.c Inf_M24C02.c
  group Hardware/tim
    ./Hardware/tim/: Driver_systick.c Driver_tim6.c Driver_tim5.c Driver_tim4.c Driver_tim1.c
  group Hardware/dma
    ./Hardware/dma/: Driver_DMA1.c Driver_DMA1_RX.c
  group Hardware/adc
    ./Hardware/ADC/: Driver_ADC_single.c Driver_ADC_doube.c
  group Hardware/spi
    ./Hardware/spi/: Driver_spi.c Inf_W25Q32.c
  group Hardware/fsmc
    ./Hardware/fsmc/: Driver_FSMC.c
  group Hardware/lcd
    ./Hardware/lcd/: Driver_LCD_FSMC.c Inf_LCD.c
